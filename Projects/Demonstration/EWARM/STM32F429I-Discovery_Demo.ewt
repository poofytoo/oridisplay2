<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>STM32F429I-Discovery_Demo</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>Appli</name>
    <group>
      <name>Test</name>
      <file>
        <name>$PROJ_DIR$\..\Core\Test_Program\frame_view.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Core\Test_Program\test_program.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Core\Test_Program\usbd_desc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Core\Test_Program\usbd_usr.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\STemWin_Library_V1.1.2\Libraries\STemWinLibrary522\Software\WindowDLG.c</name>
      </file>
    </group>
    <group>
      <name>User</name>
      <file>
        <name>$PROJ_DIR$\..\Core\User\bsp.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Core\User\fatfs_drv.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Core\User\main.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Core\User\rtc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\startup_stm32f429_439xx.s</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Core\User\stm32xxx_it.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Core\Devices\STM32F4xx\system_stm32f4xx.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Core\User\usb_bsp.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Core\User\usbh_usr.c</name>
      </file>
    </group>
    <group>
      <name>Utils</name>
      <file>
        <name>$PROJ_DIR$\..\Core\Lib\cpu_utils.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Core\Lib\file_utils.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Core\Lib\str_utils.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Core\Lib\time_utils.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>Libraries</name>
    <group>
      <name>STemWinLibrary522_4x9i</name>
      <group>
        <name>Config</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\Libraries\STemWinLibrary522_4x9i\Config\GUIConf.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\Libraries\STemWinLibrary522_4x9i\Config\GUIDRV_stm32f429i_discovery.c</name>
        </file>
      </group>
      <group>
        <name>Lib</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\Libraries\STemWinLibrary522_4x9i\Lib\STemWin522_4x9i_CM4_OS_IAR.a</name>
        </file>
      </group>
      <group>
        <name>OS</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\Libraries\STemWinLibrary522_4x9i\OS\GUI_X_FreeRTOS.c</name>
        </file>
      </group>
    </group>
    <group>
      <name>STM32429I-DISCO</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\Utilities\STM32F429I-Discovery\stm32f429i_discovery.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Utilities\STM32F429I-Discovery\stm32f429i_discovery_ioe.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Utilities\STM32F429I-Discovery\stm32f429i_discovery_l3gd20.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Utilities\STM32F429I-Discovery\stm32f429i_discovery_lcd.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Utilities\STM32F429I-Discovery\stm32f429i_discovery_sdram.c</name>
      </file>
    </group>
    <group>
      <name>STM32_USB</name>
      <group>
        <name>Device</name>
        <group>
          <name>Class</name>
          <group>
            <name>HID</name>
            <file>
              <name>$PROJ_DIR$\..\..\..\Libraries\STM32_USB_Device_Library\Class\hid\src\usbd_hid_core.c</name>
            </file>
          </group>
        </group>
        <group>
          <name>Core</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\Libraries\STM32_USB_Device_Library\Core\src\usbd_core.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\Libraries\STM32_USB_Device_Library\Core\src\usbd_ioreq.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\Libraries\STM32_USB_Device_Library\Core\src\usbd_req.c</name>
          </file>
        </group>
      </group>
      <group>
        <name>Driver</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\Libraries\STM32_USB_OTG_Driver\src\usb_core.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\Libraries\STM32_USB_OTG_Driver\src\usb_dcd.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\Libraries\STM32_USB_OTG_Driver\src\usb_dcd_int.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\Libraries\STM32_USB_OTG_Driver\src\usb_hcd.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\Libraries\STM32_USB_OTG_Driver\src\usb_hcd_int.c</name>
        </file>
      </group>
      <group>
        <name>Host</name>
        <group>
          <name>Class</name>
          <group>
            <name>MSC</name>
            <file>
              <name>$PROJ_DIR$\..\..\..\Libraries\STM32_USB_HOST_Library\Class\MSC\src\usbh_msc_bot.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\Libraries\STM32_USB_HOST_Library\Class\MSC\src\usbh_msc_core.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\Libraries\STM32_USB_HOST_Library\Class\MSC\src\usbh_msc_scsi.c</name>
            </file>
          </group>
        </group>
        <group>
          <name>Core</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\Libraries\STM32_USB_HOST_Library\Core\src\usbh_core.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\Libraries\STM32_USB_HOST_Library\Core\src\usbh_hcs.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\Libraries\STM32_USB_HOST_Library\Core\src\usbh_ioreq.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\Libraries\STM32_USB_HOST_Library\Core\src\usbh_stdreq.c</name>
          </file>
        </group>
      </group>
    </group>
    <group>
      <name>STM32F4xx_StdPeriph_Driver</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\src\misc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_adc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_dcmi.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_dma.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_dma2d.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_exti.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_flash.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_fmc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_fsmc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_gpio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_i2c.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_ltdc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_pwr.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_rcc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_rng.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_rtc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_sdio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_spi.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_syscfg.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_tim.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_usart.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>Utilities</name>
    <group>
      <name>FAT_FS</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\Utilities\Third_Party\fat_fs\src\ff.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Utilities\Third_Party\fat_fs\src\option\syscall.c</name>
      </file>
    </group>
    <group>
      <name>FreeRTOS</name>
      <group>
        <name>Core</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\Utilities\Third_Party\FreeRTOS\Source\croutine.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\Utilities\Third_Party\FreeRTOS\Source\list.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\Utilities\Third_Party\FreeRTOS\Source\queue.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\Utilities\Third_Party\FreeRTOS\Source\tasks.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\Utilities\Third_Party\FreeRTOS\Source\timers.c</name>
        </file>
      </group>
      <group>
        <name>Memory</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\Utilities\Third_Party\FreeRTOS\Source\portable\MemMang\heap_2.c</name>
        </file>
      </group>
      <group>
        <name>Portable</name>
        <group>
          <name>STM32F1xx</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\Utilities\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM3\port_cm3.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\Utilities\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM3\portasm_cm3.s</name>
          </file>
        </group>
        <group>
          <name>STM32F4xx</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\Utilities\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM4F\port_cm4.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\Utilities\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM4F\portasm_cm4.s</name>
          </file>
        </group>
      </group>
    </group>
  </group>
</project>


